options:
  parameters:
    author: Swarnava Ghosh
    copyright: Swarnava Ghosh
    generate_options: no_gui
    id: frame_deframe
    output_language: python
    title: Frame/Deframe
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: UTAT_HERON_esttc_deframer_0
  id: UTAT_HERON_esttc_deframer
  parameters:
    samp_rate: samp_rate
  states: {}
- name: UTAT_HERON_esttc_framer_0
  id: UTAT_HERON_esttc_framer
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(4, [1,2,3,4]))
    period: '1000'
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}

connections:
- [UTAT_HERON_esttc_deframer_0, crc_fail, blocks_message_debug_0, log]
- [UTAT_HERON_esttc_deframer_0, crc_ok, blocks_message_debug_0, log]
- [UTAT_HERON_esttc_framer_0, pdu_out, pdu_pdu_to_tagged_stream_0, pdus]
- [blocks_message_strobe_0, strobe, UTAT_HERON_esttc_framer_0, pdu_in]
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_tag_gate_0, '0']
- [blocks_tag_gate_0, '0', UTAT_HERON_esttc_deframer_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
